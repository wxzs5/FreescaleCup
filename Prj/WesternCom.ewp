# IAR project WesternCom.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK60FN1M0xxx15 Freescale MK60FN1M0xxx15
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: DEBUG; ARM_MATH_CM4; MK60F15; MK60FN15
  ICCARM.CCIncludePath2: ..\App; ..\App\Inc; ..\Board\Inc; ..\Chip\inc; ..\Chip\inc\IAR; ..\Chip\inc\kinetis; ..\Lib\CMSIS\Inc; ..\Lib\FatFs; ..\Lib\USB; ..\User\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: WesternCom.hex
  ILINK.IlinkOutputFile: WesternCom.out
  ILINK.IlinkIcfFile: config files\vcan_ROM_K60N1M.icf
  ILINK.IlinkAdditionalLibs: ..\Lib\CMSIS\iar_cortexM4l_math.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group App
    ../App/: main.c MK60_conf.c MK60_it.c
  group App/Inc
    ../App/Inc/: include.h MK60_conf.h MK60_it.h PORT_cfg.h
  group Board/inc
    ../Board/inc/: VCAN_ASCII.h VCAN_BMP.h VCAN_camera.h VCAN_computer.h vcan_img2sd.h VCAN_key.h VCAN_key_event.h VCAN_LCD.h VCAN_LCD_CH.h VCAN_LCD_ILI9341.h VCAN_LCD_ST7735R.h VCAN_LCD_ST7735S.h VCAN_LED.H VCAN_MMA7455.h VCAN_NRF24L0.h VCAN_NRF24L0_MSG.h VCAN_OV7725_Eagle.h VCAN_OV7725_REG.h VCAN_OV7725_Wolf.h VCAN_RTC_count.h VCAN_SCCB.h vcan_sd_app.h Vcan_touch.h VCAN_TSL1401.h vcan_ui_var.h
  group Board/src
    ../Board/src/: VCAN_ASCII.c VCAN_BMP.c VCAN_camera.c VCAN_computer.c vcan_img2sd.c VCAN_key.c VCAN_key_event.c VCAN_LCD.c VCAN_LCD_CH.c VCAN_LCD_ILI9341.c VCAN_LCD_ST7735R.c VCAN_LCD_ST7735S.c VCAN_LED.C VCAN_MMA7455.c VCAN_NRF24L0.c VCAN_NRF24L0_MSG.c VCAN_OV7725_Eagle.c VCAN_OV7725_Wolf.c VCAN_RTC_count.C VCAN_SCCB.c vcan_sd_app.c Vcan_touch.c VCAN_TSL1401.c VCAN_UI_VAR.c
  group Chip/inc
    ../Chip/inc/: common.h misc.h MK60_adc.h MK60_can.h MK60_dac.h MK60_dma.h MK60_DWT.h MK60_FLASH.h MK60_flexbus.h MK60_FTM.h MK60_gpio.h MK60_gpio_cfg.h MK60_i2c.h MK60_lptmr.h MK60_mcg.h MK60_pit.h MK60_port.h MK60_rtc.h MK60_sdhc.h MK60_spi.h MK60_SysTick.h MK60_uart.h MK60_usb.h MK60_wdog.h vectors.h
  group Chip/inc/IAR
    ../Chip/inc/IAR/: iar.h system_MK60DZ10.h
  group Chip/inc/kinetis
    ../Chip/inc/kinetis/: MK10DZ10.h MK20DZ10.h MK30DZ10.h MK40DZ10.h MK50DZ10.h MK51DZ10.h MK52DZ10.h MK53DZ10.h MK60DZ10.h MK60F12.h MK60F15.h MK61F12.h MK61F15.h MK70F12.h MK70F15.h
  group Chip/src
    ../Chip/src/: misc.c MK60_adc.c MK60_can.c MK60_dac.c MK60_dma.c MK60_DWT.c MK60_flash.c MK60_flexbus.c MK60_ftm.c MK60_gpio.c MK60_i2c.c MK60_lptmr.c MK60_mcg.c MK60_PIT.c MK60_port.c MK60_rtc.c MK60_sdhc.c MK60_spi.c MK60_SysTick.c MK60_uart.c MK60_usb.c MK60_wdog.c vectors.c
  group Chip/src/IAR
    ../Chip/src/IAR/: startup_MK60DZ10.s system_MK60DZ10.c
  group Lib/CMSIS
    ../Lib/CMSIS/: iar_cortexM4l_math.a iar_cortexM4lf_math.a
  group Lib/CMSIS/Inc
    ../Lib/CMSIS/Inc/: arm_common_tables.h arm_const_structs.h arm_math.h core_cm0.h core_cm0plus.h core_cm3.h core_cm4.h core_cm4_simd.h core_cmFunc.h core_cmInstr.h core_sc000.h core_sc300.h
  group Lib/FatFs
    ../Lib/FatFs/: diskio.c diskio.h ff.c ff.h ffconf.h integer.h
  group Lib/USB
    ../Lib/USB/: FslTypes.h USB.c usb.h USB_CDC.c USB_CDC.h USB_Desc.h
  group User/inc
    ../User/inc/: Calculate.h CCD.h control.h fuzzy.h Init.h key_int.h main.h motor.h OLED.h PID.h PIT0.h process.h Serial_oscilloscope.h Struct.h
  group User/src
    ../User/src/: Calculate.c CCD.c control.c fuzzy.c Init.c key_int.c motor.c OLED.c PID.c PIT0.c process.c Serial_oscilloscope.c Struct.c
