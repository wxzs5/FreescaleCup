<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>App</name>
    <group>
      <name>Inc</name>
      <file>
        <name>$PROJ_DIR$\..\App\Inc\include.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\App\Inc\MK60_conf.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\App\Inc\MK60_it.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\App\Inc\PORT_cfg.h</name>
      </file>
    </group>
    <file>
      <name>$PROJ_DIR$\..\App\main.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\App\MK60_conf.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\App\MK60_it.c</name>
    </file>
  </group>
  <group>
    <name>Board</name>
    <group>
      <name>inc</name>
      <file>
        <name>$PROJ_DIR$\..\Board\inc\VCAN_ASCII.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Board\inc\VCAN_BMP.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Board\inc\VCAN_camera.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Board\inc\VCAN_computer.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Board\inc\vcan_img2sd.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Board\inc\VCAN_key.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Board\inc\VCAN_key_event.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Board\inc\VCAN_LCD.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Board\inc\VCAN_LCD_CH.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Board\inc\VCAN_LCD_ILI9341.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Board\inc\VCAN_LCD_ST7735R.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Board\inc\VCAN_LCD_ST7735S.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Board\inc\VCAN_LED.H</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Board\inc\VCAN_MMA7455.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Board\inc\VCAN_NRF24L0.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Board\inc\VCAN_NRF24L0_MSG.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Board\inc\VCAN_OV7725_Eagle.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Board\inc\VCAN_OV7725_REG.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Board\inc\VCAN_OV7725_Wolf.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Board\inc\VCAN_RTC_count.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Board\inc\VCAN_SCCB.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Board\inc\vcan_sd_app.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Board\inc\Vcan_touch.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Board\inc\VCAN_TSL1401.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Board\inc\vcan_ui_var.h</name>
      </file>
    </group>
    <group>
      <name>src</name>
      <file>
        <name>$PROJ_DIR$\..\Board\src\VCAN_ASCII.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Board\src\VCAN_BMP.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Board\src\VCAN_camera.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Board\src\VCAN_computer.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Board\src\vcan_img2sd.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Board\src\VCAN_key.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Board\src\VCAN_key_event.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Board\src\VCAN_LCD.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Board\src\VCAN_LCD_CH.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Board\src\VCAN_LCD_ILI9341.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Board\src\VCAN_LCD_ST7735R.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Board\src\VCAN_LCD_ST7735S.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Board\src\VCAN_LED.C</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Board\src\VCAN_MMA7455.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Board\src\VCAN_NRF24L0.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Board\src\VCAN_NRF24L0_MSG.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Board\src\VCAN_OV7725_Eagle.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Board\src\VCAN_OV7725_Wolf.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Board\src\VCAN_RTC_count.C</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Board\src\VCAN_SCCB.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Board\src\vcan_sd_app.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Board\src\Vcan_touch.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Board\src\VCAN_TSL1401.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Board\src\VCAN_UI_VAR.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>Chip</name>
    <group>
      <name>inc</name>
      <group>
        <name>IAR</name>
        <file>
          <name>$PROJ_DIR$\..\Chip\inc\IAR\iar.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Chip\inc\IAR\system_MK60DZ10.h</name>
        </file>
      </group>
      <group>
        <name>kinetis</name>
        <file>
          <name>$PROJ_DIR$\..\Chip\inc\kinetis\MK10DZ10.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Chip\inc\kinetis\MK20DZ10.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Chip\inc\kinetis\MK30DZ10.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Chip\inc\kinetis\MK40DZ10.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Chip\inc\kinetis\MK50DZ10.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Chip\inc\kinetis\MK51DZ10.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Chip\inc\kinetis\MK52DZ10.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Chip\inc\kinetis\MK53DZ10.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Chip\inc\kinetis\MK60DZ10.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Chip\inc\kinetis\MK60F12.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Chip\inc\kinetis\MK60F15.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Chip\inc\kinetis\MK61F12.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Chip\inc\kinetis\MK61F15.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Chip\inc\kinetis\MK70F12.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Chip\inc\kinetis\MK70F15.h</name>
        </file>
      </group>
      <file>
        <name>$PROJ_DIR$\..\Chip\inc\common.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Chip\inc\misc.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Chip\inc\MK60_adc.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Chip\inc\MK60_can.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Chip\inc\MK60_dac.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Chip\inc\MK60_dma.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Chip\inc\MK60_DWT.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Chip\inc\MK60_FLASH.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Chip\inc\MK60_flexbus.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Chip\inc\MK60_FTM.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Chip\inc\MK60_gpio.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Chip\inc\MK60_gpio_cfg.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Chip\inc\MK60_i2c.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Chip\inc\MK60_lptmr.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Chip\inc\MK60_mcg.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Chip\inc\MK60_pit.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Chip\inc\MK60_port.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Chip\inc\MK60_rtc.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Chip\inc\MK60_sdhc.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Chip\inc\MK60_spi.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Chip\inc\MK60_SysTick.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Chip\inc\MK60_uart.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Chip\inc\MK60_usb.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Chip\inc\MK60_wdog.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Chip\inc\vectors.h</name>
      </file>
    </group>
    <group>
      <name>src</name>
      <group>
        <name>IAR</name>
        <file>
          <name>$PROJ_DIR$\..\Chip\src\IAR\startup_MK60DZ10.s</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Chip\src\IAR\system_MK60DZ10.c</name>
        </file>
      </group>
      <file>
        <name>$PROJ_DIR$\..\Chip\src\misc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Chip\src\MK60_adc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Chip\src\MK60_can.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Chip\src\MK60_dac.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Chip\src\MK60_dma.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Chip\src\MK60_DWT.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Chip\src\MK60_flash.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Chip\src\MK60_flexbus.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Chip\src\MK60_ftm.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Chip\src\MK60_gpio.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Chip\src\MK60_i2c.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Chip\src\MK60_lptmr.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Chip\src\MK60_mcg.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Chip\src\MK60_PIT.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Chip\src\MK60_port.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Chip\src\MK60_rtc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Chip\src\MK60_sdhc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Chip\src\MK60_spi.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Chip\src\MK60_SysTick.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Chip\src\MK60_uart.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Chip\src\MK60_usb.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Chip\src\MK60_wdog.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Chip\src\vectors.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>Lib</name>
    <group>
      <name>CMSIS</name>
      <group>
        <name>Inc</name>
        <file>
          <name>$PROJ_DIR$\..\Lib\CMSIS\Inc\arm_common_tables.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Lib\CMSIS\Inc\arm_const_structs.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Lib\CMSIS\Inc\arm_math.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Lib\CMSIS\Inc\core_cm0.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Lib\CMSIS\Inc\core_cm0plus.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Lib\CMSIS\Inc\core_cm3.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Lib\CMSIS\Inc\core_cm4.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Lib\CMSIS\Inc\core_cm4_simd.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Lib\CMSIS\Inc\core_cmFunc.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Lib\CMSIS\Inc\core_cmInstr.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Lib\CMSIS\Inc\core_sc000.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\Lib\CMSIS\Inc\core_sc300.h</name>
        </file>
      </group>
      <file>
        <name>$PROJ_DIR$\..\Lib\CMSIS\iar_cortexM4l_math.a</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Lib\CMSIS\iar_cortexM4lf_math.a</name>
      </file>
    </group>
    <group>
      <name>FatFs</name>
      <file>
        <name>$PROJ_DIR$\..\Lib\FatFs\diskio.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Lib\FatFs\diskio.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Lib\FatFs\ff.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Lib\FatFs\ff.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Lib\FatFs\ffconf.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Lib\FatFs\integer.h</name>
      </file>
    </group>
    <group>
      <name>USB</name>
      <file>
        <name>$PROJ_DIR$\..\Lib\USB\FslTypes.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Lib\USB\USB.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Lib\USB\usb.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Lib\USB\USB_CDC.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Lib\USB\USB_CDC.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\Lib\USB\USB_Desc.h</name>
      </file>
    </group>
  </group>
  <group>
    <name>User</name>
    <group>
      <name>inc</name>
      <file>
        <name>$PROJ_DIR$\..\User\inc\Calculate.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\User\inc\CCD.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\User\inc\control.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\User\inc\fuzzy.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\User\inc\Init.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\User\inc\key_int.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\User\inc\main.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\User\inc\motor.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\User\inc\OLED.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\User\inc\PID.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\User\inc\PIT0.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\User\inc\process.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\User\inc\Serial_oscilloscope.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\User\inc\Struct.h</name>
      </file>
    </group>
    <group>
      <name>src</name>
      <file>
        <name>$PROJ_DIR$\..\User\src\Calculate.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\User\src\CCD.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\User\src\control.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\User\src\fuzzy.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\User\src\Init.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\User\src\key_int.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\User\src\motor.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\User\src\OLED.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\User\src\PID.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\User\src\PIT0.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\User\src\process.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\User\src\Serial_oscilloscope.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\User\src\Struct.c</name>
      </file>
    </group>
  </group>
</project>


